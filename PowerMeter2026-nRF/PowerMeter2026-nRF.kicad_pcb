# Repository KUBTSSAvionics/PowerMeter2026

File README.md:

# PowerMeter2026
PowerMeter2026

## KiCad design PowerMeter2026-nRF/PowerMeter2026-nRF.kicad_pcb

Parts:
BT2: Battery_Cell; BatteryCell
C4, C8: 0.1u; C_0603_1608Metric
C5, C6, C7, C13, C15: 1u; C_0603_1608Metric
C14: 220u; C_0603_1608Metric
D6: RB160M; D_SOD-123
J3, J4: Conn_JST_PHD_S10B_PHDSS; JST_PHD_S10B-PHDSS_2x05_P2.00mm_Horizontal
J5: STRAIN_R; PinHeader_1x04_P2.54mm_Vertical
Q1: AO3401A; SOT-23
R3: 22k; R_0603_1608Metric
R4, R5: 100k; R_0603_1608Metric
R11, R12: 100; R_0603_1608Metric
SW2: CELL; toggle
U2: nRF52840 sense; nRF52840 XIAO Sense
U3: TPS76133SF5; SOT-23-5
U5: ADS131M02; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3V3: C7.1, C13.2, C15.2, D6.2 (A), J3.10, Q1.3 (S), U3.5 (OUT), U5.1 (AVDD), U5.11 (SYNC/RST), U5.20 (DVDD)
+3V3_M: J4.2, U2.3V3
+VDD: J5.1, Q1.2 (D), U5.6 (AIN1P)
ADC_BAT: C8.1, J3.8, R4.1, R5.1
ADC_BAT_M: J4.4, U2.P1.11 (D6/TX)
CLK: J3.7, U5.17 (CLKIN)
CLK_M: J4.3, U2.P0.02 (D0/A0)
CS: J3.4, U5.12 (CS)
CS_M: J4.8, U2.P1.12 (D7/RX)
DRDY: J3.2, U5.13 (DRDY)
DRDY_M: J4.10, U2.P0.03 (D1/A1)
GND: BT2.2 (-), C5.2, C6.2, C7.2, C8.2, C13.1, C14.1, C15.1, J3.6, J5.4, R5.2, U3.2 (GND), U5.2 (AGND), U5.5 (AIN1N), U5.19 (DGND)
GND_M: J4.6, U2.GND
INNA: J5.3, R12.1
INPA: J5.2, R11.1
MISO: J3.3, U5.15 (DOUT)
MISO_M: J4.7, U2.P1.14 (D9/MISO)
MOSI: J3.5, U5.16 (DIN)
MOSI_M: J4.5, U2.P1.15 (D10/MOSI)
unnamed: BT2.1 (+), SW2.1 (A)
unnamed: C6.1, D6.1 (K), R3.1, R4.2, SW2.2 (B), U3.1 (IN)
unnamed: C5.1, R3.2, U3.3 (~EN)
unnamed: C4.1, R12.2, U5.4 (AIN0N)
unnamed: C4.2, R11.2, U5.3 (AIN0P)
unnamed: C14.2, U5.18 (CAP)
SCK: J3.1, U5.14 (SCLK)
SCK_M: J4.9, U2.P1.13 (D8/SCK)
SW: J3.9, Q1.1 (G)
SW_M: J4.1, U2.P0.28 (D2/A2)

Notes on the sheet:
max:150mA
スライドスイッチ
ひずみゲージ
3.7V
AGNDとDGNDはデバイスの近くで一点接続することが推奨されている

Board: 2 copper layers, 72.1 x 47.9 mm, 23 parts (17 on the bottom side), 29 nets.

## Commit log

2025-09-17 Update README.md
    PowerMeter2026 Yokoyama Chisa 2025.09.17
2025-09-30 Add files via upload
    3軸ジャイロからホール素子に変更 2025.09.30
2025-10-03 Add files via upload
    安定化させた
2025-11-03 Add files via upload
    マイコンをnRF52840に変更
2025-12-01 Add files via upload
    フットプリント設定完了。未配線。
2026-03-04 Add files via upload
    配線完了。基板設計完了。
2026-03-05 Add files via upload
    ガーバーファイル追加。
2026-05-11 Add files via upload
    再発注後
